# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32L053R8Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STCubeGenerated +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../Inc;C:/Users/senpronics/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Inc;C:/Users/senpronics/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;C:/Users/senpronics/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Device/ST/STM32L0xx/Include;C:/Users/senpronics/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    C:/Users/senpronics/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rng.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
